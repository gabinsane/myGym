Commit message: Modify room

File: myGym/envs/objects/hack_objects/target.urdf (robot description, URDF)
Before this commit: robot cylinder, 1 links, 0 joints
Links:
- link base: geometry collision cylinder length=0.01 radius=0.35; visual cylinder length=0.01 radius=0.35
